require rauc-disk-updater.inc

SRC_URI = "https://github.com/helbling-technik-gmbh/rauc-disk-updater/releases/download/v${PV}/rauc-disk-updater-${PV}.tar.xz"
SRC_URI[md5sum] = "fa80544fac7ad55177f0d87efc9a9a0d"
SRC_URI[sha256sum] = "e3a1bc3eb65bc2e97c70dee768865e8db3139284b94c8c859ac03a53e88bef4f"
